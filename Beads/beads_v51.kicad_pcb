# Repository kstammits/Mutable

## KiCad design Beads/beads_v51.kicad_pcb

Board: 4 copper layers, 151.2 x 128.5 mm, 231 parts (38 on the bottom side), 147 nets.

Parts:
C1, C2: 10u; C0805
C3, C4, C6, C7, C16, C18, C28, C29: 10u; C0603
C5, C9, C12, C13, C14, C15, C21, C22, C25, C26, C27, C30, C33, C36, C41, C42, C45, C46, C47, C48, C50, C52, C53, C56, C58, C61, C62, C63, C65, C67, C68, C70, C71: 100n; C0402
C8, C11, C19: 1.0n; C0402
C10, C17, C66, C69, C72: 2.2u; C0402
C20, C23, C24: 2.2n; C0402
C31, C32, C37, C40: 220p; C0402
C34, C35: 2.2n; C0603
C38, C39, C64: 1.2n; C0402
C43, C44: 680p; C0402
C49, C51: 330p; C0402
C54, C55, C59: 47u; C0805
C57, C60: 18p; C0402
D1, D2: 1N5819HW; SOD123
D3: BAT54S; SOT23
D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15: 16V; 0603
IC1: MCP16311MS; MSOP-8
IC2, IC4: MCP6004; TSSOP14_065
IC3: LM4040B10; DBZ_R-PDSO-G3
IC5: LD2981ABU33; SOT89
IC6: UA78M05DCY; SOT223
IC7: PCM3060; TSSOP28
IC8: 4051PW; TSSOP16_065
IC9, IC10: NJM2068; TSSOP08
IC11: STM32H743VIT6; TQFP100
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12: PJ301_THONKICONNTME; WQP_PJ_301M_TME
JP1: M05X2SHD; 2X5-SHROUDED
JP2: 1X04
JP3: 1X02
L1, L2, L5, L6, L7, L11, L12: 1k@1MHz; 0603
L3: 15u/0.73A; R1210
L4: 1u/0.75A; R1210
LED1: ASMB-KTF0-0A306; PLCC-4-2220
LED2, LED3, LED4, LED5: INL-3AW30; LED3MM
Q1: 8MHz; CTS406
R1, R4: 39; R0402
R2, R3, R90: 220; R0402
R5, R11, R14, R15, R17, R36, R49, R68, R70, R75, R80, R81, R82, R83, R84: 10k; R0402
R6: 31.6k; R0402
R7, R22, R23, R44, R45: 10kB; ALPS_POT_VERTICAL_PS
R8, R21, R29, R33, R35, R38, R78, R79, R87, R88: 100k; R0402
R9, R12, R18, R19, R30: 33k; R0402
R10, R20, R56, R57, R58, R59: 1.0k; R0402
R13, R16, R28: 200k; R0402
R24, R25, R26, R27, R67, R69, R91, R92, R93, R94: 2.0k; R0402
R31, R40, R41: 20k; R0402
R32, R37: 33; R1206
R34, R39, R42: 120k; R0402
R43, R46, R62, R63, R64, R65, R66: 10kB; ALPS_POT_NARROW
R47, R89, R95: 100; R0402
R48: 220k; R0402
R50, R51, R52, R53, R73, R74: 12k; R0402
R54, R55, R60, R61: 30k; R0402
R71, R72: 8.2k; R0402
R76, R77: 1.0k; R0603
R85, R86: 1.0M; R0402
SW1, SW2: LP4OA1PBCT
SW3, SW4: TACTILE_SWITCH_SMD_JLEAD
U$1: VLP-XXX-X
U$2: ROHS_BIG
U$3: FCC_MEDIUM
U$4: CE_MEDIUM

Connections:
+3V3: C6.1, C7.1, C61.1, C62.1, C67.1, C68.1, C70.1, C71.1, D3.2, IC11.6, IC11.11, IC11.27, IC11.50, IC11.75, IC11.100, L3.2, LED1.1, R6.1, R36.1
+3V3_A: C9.1, C17.1, C22.1, C27.1, C65.1, C66.1, IC2.4, IC4.4, IC5.1, IC8.16, IC11.20, IC11.21, L7.1, R7.P$1, R14.2, R15.2, R22.P$1, R23.P$1, R43.P$1, R44.P$1, R45.P$1, R46.P$1, R62.P$1, R63.P$1, R64.P$1, R65.P$1, R66.P$1
+5V_A: C21.1, IC6.3, L6.2, L11.1
-10V: C13.1, IC3.2, R13.1, R16.1, R24.2, R28.1, R34.1, R39.1, R42.1
ASSIGN_CV: C8.2, IC2.1, IC11.22, R9.2
ASSIGN_LED_1: IC11.60, R94.1
ASSIGN_LED_2: IC11.61, R93.1
ASSIGN_LED_3: IC11.62, R92.1
ASSIGN_SW: IC11.37, SW4.3, SW4.4
AUDIO_INL: C28.2, IC7.25
AUDIO_INR: C29.2, IC7.26
AUDIO_MCK: IC7.6, IC7.9, R47.2
AUDIO_MCK_RAW: IC11.1, R47.1
AUDIO_MISO: IC7.3, IC11.2
AUDIO_MOSI: IC7.12, IC11.5
AUDIO_RESET: IC7.15, IC11.7, R49.2
AUDIO_SCK: IC7.5, IC7.10, R89.2
AUDIO_SCK_RAW: IC11.4, R89.1
AUDIO_WS: IC7.4, IC7.11, R95.2
AUDIO_WS_RAW: IC11.3, R95.1
DENSITY_CV: C11.2, IC2.7, IC11.23, R19.2
DENSITY_POT: C12.1, IC11.29, R7.P$2
FEEDBACK_POT: C36.1, IC8.13, R43.P$2
FREEZE: IC2.8, IC11.47, R18.2
FREEZE_LED: IC11.63, R4.2
FREEZE_SW: IC11.70, SW1.P2, SW1.P5
GND: C1.1, C2.2, C3.2, C4.2, C6.2, C7.2, C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C21.2, C22.2, C25.2, C26.2, C27.2, C30.2, C33.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.1, C42.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.1, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, D9.1, D10.1, D11.1, D12.1, D13.1, D14.1, D15.1, IC1.5, IC1.8, IC2.3, IC2.5, IC2.11, IC3.1, IC4.3, IC4.5, IC4.10, IC4.11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
INPUT_LED: IC11.65, R91.1
MEDIA_LED_B: IC11.43, R26.1
MEDIA_LED_G: IC11.41, R25.1
MEDIA_LED_R: IC11.39, R27.1
MEDIA_SW: IC11.38, SW3.3, SW3.4
unnamed: C3.1, C4.1, IC1.3, IC1.4, L4.2
unnamed: D6.2, J9.P3, R17.1, R87.2
unnamed: C40.1, IC9.5, R59.2
unnamed: C57.1, Q1.1, R90.2
unnamed: JP3.2, R2.1
unnamed: JP3.1, R3.1
unnamed: C8.1, IC2.2, R8.2, R9.1, R13.2
unnamed: D4.2, J1.P3, R8.1
unnamed: J5.P2, R83.2
unnamed: C19.1, IC4.2, R28.2, R30.1, R33.2
unnamed: D9.2, J5.P3, R33.1
unnamed: R1.1, SW2.L1
unnamed: C24.1, IC4.9, R35.2, R39.2, R41.1
unnamed: D5.2, J3.P3, R35.1
unnamed: J3.P2, R82.2
unnamed: C11.1, IC2.6, R16.2, R19.1, R21.2
unnamed: D11.2, J6.P3, R21.1
unnamed: C23.1, IC4.6, R38.2, R40.1, R42.2
unnamed: D14.2, J2.P3, R38.1
unnamed: J2.P2, R81.2
unnamed: C20.1, IC4.13, R29.2, R31.1, R34.2
unnamed: D7.2, J4.P3, R29.1
unnamed: J4.P2, R75.2
unnamed: J10.P2, R80.2
unnamed: D15.2, J8.P3, R74.1, R79.2
unnamed: IC2.9, R17.2
unnamed: D8.2, J10.P3, R11.1, R88.2
unnamed: IC2.10, R15.1, R18.1, R20.2
unnamed: IC2.13, R11.2
unnamed: IC2.12, R10.2, R12.1, R14.1
unnamed: C16.1, IC5.3, R37.1
unnamed: D13.2, J7.P3, R73.1, R78.2
unnamed: C43.1, R71.1, R73.2
unnamed: LED4.A, R92.2
unnamed: C35.2, R52.2, R58.1, R60.2
unnamed: J7.P2, R86.2
unnamed: C51.1, IC10.5, R72.2
unnamed: D2.A, L1.2
unnamed: C35.1, R53.2, R54.1, R56.1
unnamed: D1.C, L2.2, L5.2, L12.2
unnamed: C34.1, R51.2, R55.1, R57.1
unnamed: C18.1, IC6.1, R32.1
unnamed: C49.1, IC10.3, R71.2
unnamed: C43.2, IC10.1, IC10.2, R68.1
unnamed: J8.P2, R85.2
unnamed: C44.2, IC10.6, IC10.7, R70.1
unnamed: C28.1, C38.1, R67.2, R68.2
unnamed: LED1.2, R27.2
unnamed: C44.1, R72.1, R74.2
unnamed: L6.1, R37.2
unnamed: C55.1, C56.1, IC7.24, L11.2
unnamed: D12.2, J12.P3, R77.1
unnamed: C29.1, C39.1, R69.2, R70.2
unnamed: J6.P2, R84.2
unnamed: D10.2, J11.P3, J12.P2, R76.1
unnamed: D2.C, JP1.1, JP1.2
unnamed: L4.1, L12.1
unnamed: C31.1, IC9.2, R56.2
unnamed: C31.2, IC9.1, R54.2, R76.2
unnamed: C32.1, IC9.6, R57.2
unnamed: C32.2, IC9.7, R55.2, R77.2
unnamed: C37.1, IC9.3, R58.2
unnamed: C34.2, R50.2, R59.1, R61.2
unnamed: L5.1, R32.2
unnamed: IC7.20, R53.1
unnamed: IC7.19, R52.1
unnamed: C58.1, C59.1, IC7.7, L7.2
unnamed: IC7.18, R51.1
unnamed: IC7.17, R50.1
unnamed: R4.1, SW1.L1
unnamed: LED5.A, R91.2
unnamed: IC7.28, R48.2
unnamed: LED1.3, R25.2
unnamed: LED1.4, R26.2
unnamed: LED2.A, R94.2
unnamed: LED3.A, R93.2
unnamed: D1.A, JP1.9, JP1.10
unnamed: C10.1, IC1.2
unnamed: C5.2, IC1.6, L3.1
unnamed: C53.1, C54.1, IC7.21
unnamed: C5.1, IC1.7
unnamed: IC1.1, R5.1, R6.2
NORMALIZATION_PROBE: D3.3, IC11.45, R75.1, R80.1, R81.1, R82.1, R83.1, R84.1, R85.1, R86.1
OSC_IN: C60.1, IC11.12, Q1.3
OSC_OUT: IC11.13, R90.1
PITCH_AMT_POT: C48.1, IC8.2, R66.P$2
PITCH_CV: C19.2, IC4.1, IC11.24, R30.2
PITCH_POT: C15.1, IC11.30, R23.P$2
POSITION_AMT_POT: C45.1, IC8.12, R63.P$2
POSITION_CV: C23.2, IC4.7, IC11.25, R40.2
POSITION_POT: C14.1, IC11.28, R22.P$2
POT_MUX: C64.1, IC8.3, IC11.18
POT_MUX_S0: IC8.11, IC11.55
POT_MUX_S1: IC8.10, IC11.56
POT_MUX_S2: IC8.9, IC11.57
RESET: C63.1, IC11.14, JP2.4, R36.2
REVERB_POT: C52.1, IC8.15, R62.P$2
RX: IC11.69, R3.2
SEED: IC2.14, IC11.46, R12.2
SEED_LED: IC11.64, R1.2
SEED_SW: IC11.71, SW2.P2, SW2.P5
SHAPE_AMT_POT: C47.1, IC8.5, R65.P$2
SHAPE_CV: C20.2, IC4.14, IC11.16, R31.2
SHAPE_POT: C25.1, IC11.32, R45.P$2
SIZE_AMT_POT: C46.1, IC8.1, R64.P$2
SIZE_CV: C24.2, IC4.8, IC11.15, R41.2
SIZE_POT: C33.1, IC11.31, R44.P$2
SWCLK: IC11.76, JP2.3
SWDIO: IC11.72, JP2.2
TX: IC11.68, R2.2
VCAP_1: C69.1, IC11.48
VCAP_2: C72.1, IC11.73
VCC: C2.1, C30.1, C42.1, IC9.8, IC10.8, L2.1
VEE: C1.2, C41.2, C50.2, IC9.4, IC10.4, L1.1, R24.1
WET_POT: C26.1, IC8.14, R46.P$2

## KiCad design Kinks/k2.kicad_pcb

Board: 2 copper layers, 99.0 x 128.5 mm, 96 parts (62 on the bottom side), 58 nets.

Parts:
C1, C2: 22u; CP_Radial_D6.3mm_P2.50mm
C3: 100p; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C5, C6, C7, C8, C9, C11: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10: 4.7u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12: 10n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: S1JL; D_DO-41_SOD81_P10.16mm_Horizontal
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: 1N4148; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
G1: Logo_Open_Hardware_Small; snail4.sm
H1, H14: MountingHole_Pad; SLOT-1
H2, H2#2, H2#3, H2#4, H2#5, H2#6, H2#7, H2#8, H2#9: J1; MountingHole_6.4mm_M6_Pad
H6, H6#2, H6#3: J2; MountingHole_6.4mm_M6_Pad
IC1: TL074; SOIC-14_3.9x8.7mm_P1.27mm
IC2: TL072; SOIC-8_3.9x4.9mm_P1.27mm
IC3: OPA4171; SOIC-14_3.9x8.7mm_P1.27mm
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12: PJ301_THONKICONN6; WQP_PJ_301M6
J13, J14, J15: Conn_01x05_Female; PinHeader_1x05_P2.54mm_Vertical
J16, J17, J18: Conn_01x05_Male; PinHeader_1x05_P2.54mm_Vertical
JP1: M05X2PTH; AVR_ICSP
Q1: MMBFJ309; SOT-23_Handsoldering
Q2, Q3: MMBT3904; SOT-23_Handsoldering
R1, R2, R3, R4, R5, R6, R8: 180; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R14, R16, R17, R18, R28, R32: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9, R10, R11, R12, R13, R15: 200k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R19, R20, R21, R22: 220k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R23, R25: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R24, R26, R29: 1.0M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R27: 470K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R30: 470k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R31: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
FROutB: IC1.14, J13.5, R15.1
FROutT: J16.5, R2.2
GND: C1.1, C2.2, C4.1, C5.2, C6.2, C7.1, C8.2, C9.1, C10.2, C12.2, D3.2 (A), H1.1, H2.1, H2#2.1, H2#3.1, H2#4.1, H2#5.1, H2#6.1, H2#7.1, H2#8.1, H2#9.1, H6.1, H6#2.1, H6#3.1, H14.1, IC1.3 (+), IC1.5 (+), IC1.10 (+), IC1.12 (+), IC3.5 (+), J1.P1 (1), J1.P2 (2), J2.P1 (1), J3.P1 (1), J4.P1 (1), J5.P1 (1), J5.P2 (2), J6.P1 (1), J6.P2 (2), J7.P1 (1), J8.P1 (1), J9.P1 (1), J10.P1 (1), J10.P2 (2), J11.P1 (1), J12.P1 (1), J13.2, J14.3, J15.2, J16.2, J17.3, J18.2, JP1.3, JP1.4, JP1.5, JP1.6, JP1.7, JP1.8, Q3.2 (E), R7.1, R24.2, R25.1, R28.1
HROutB: IC1.1, J13.4, R13.1
HROutT: J16.4, R3.2
InvOutB: IC1.8, J13.3, R11.1
InvOutT: J16.3, R1.2
LogAB: D8.1 (K), D9.2 (A), J14.1
LogAT: J5.P3 (3), J17.1
LogBB: D6.1 (K), D7.2 (A), J14.2
LogBT: J6.P3 (3), J17.2
MaxOutB: D11.2 (A), IC2.7, J14.4
MaxOutT: J17.4, R5.2
MinOutB: D10.1 (K), IC2.1, J14.5
MinOutT: J17.5, R4.2
unnamed: C11.2, R32.2
unnamed: D1.2 (A), JP1.1, JP1.2
unnamed: D2.1 (K), JP1.9, JP1.10
unnamed: D4.2 (A), D5.1 (K), IC1.7
unnamed: D4.1 (K), IC1.6 (-), R9.1, R18.2
unnamed: D5.2 (A), R14.2, R16.2, R17.2, R18.1
unnamed: D6.2 (A), D8.2 (A), IC2.3 (+), R19.1
unnamed: D7.1 (K), D9.1 (K), IC2.5 (+), R21.1
unnamed: D10.2 (A), IC2.2 (-), R20.1
unnamed: D11.1 (K), IC2.6 (-), R22.1
unnamed: D12.2 (A), Q1.3 (G), R29.1
unnamed: D12.1 (K), IC3.8
unnamed: IC1.2 (-), R13.2, R16.1
unnamed: IC1.9 (-), R10.1, R11.2
unnamed: IC1.13 (-), R12.1, R14.1, R15.2, R17.1
unnamed: IC3.1, IC3.2 (-), Q1.2 (D), R29.2
unnamed: IC3.6 (-), R27.2, R32.1
unnamed: IC3.10 (+), R23.2, R28.2
unnamed: IC3.9 (-), R25.2, R26.1
unnamed: C12.1, IC3.12 (+), Q1.1 (S)
unnamed: J2.P3 (3), R1.1
unnamed: J3.P3 (3), R3.1
unnamed: J4.P3 (3), R2.1
unnamed: J7.P3 (3), R5.1
unnamed: J8.P3 (3), R4.1
unnamed: C3.1, J10.P3 (3), R7.2
unnamed: J9.P2 (2), J11.P3 (3), R6.1
unnamed: J12.P3 (3), R8.1
unnamed: Q2.1 (B), Q3.1 (B)
unnamed: C10.1, Q2.2 (E), R30.2
unnamed: C11.1, Q3.3 (C), R31.1
NoiseB: IC3.7, J15.1, R27.1
NoiseT: J18.1, R6.2
SHInB: IC3.3 (+), J15.4, R24.1
SHInT: J9.P3 (3), J18.4
SHOutB: IC3.13 (-), IC3.14, J15.3
SHOutT: J18.3, R8.2
SignInB: J13.1, R9.2, R10.2, R12.2
SignInT: J1.P3 (3), J16.1
TrigInB: J15.5, R23.1
TrigInT: C3.2, D3.1 (K), J18.5
VCC: C2.1, C5.1, C6.1, C8.1, D1.1 (K), IC1.4 (V+), IC2.8 (V+), IC3.4 (V+), R19.2, R20.2, R26.2, R30.1, R31.2
VEE: C1.2, C4.2, C7.2, C9.2, D2.2 (A), IC1.11 (V-), IC2.4 (V-), IC3.11 (V-), R21.2, R22.2

## Commit log (part)

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2024-08-27 version of kicad

Notices in the files:
Beads/beads_v51.kicad_pcb:
cc-by-sa
Kinks/k2.kicad_pcb:
cc-by-sa-3.0
